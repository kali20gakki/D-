# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\DSP_LIB;..\DSP_LIB\Include;..\HARDWARE\LCD;..\HARDWARE\RNG;..\HARDWARE\EXTI;..\HARDWARE\ADC;..\HARDWARE\USART3;..\HARDWARE\MENU;..\HARDWARE\RELAY;..\HARDWARE\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LCD/: ili9341.c
    ../HARDWARE/menu/: menu.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/TIM/: tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rng.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_dac.c
  group DSPLIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group README
    ../: readme.txt
